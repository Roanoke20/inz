# Keil uVision project central.uvprojx, settings and files
target superBike (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: central
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 ENABLE_DEBUG_LOG_SUPPORT DM_DISABLE_LOGS
  c misc: --c99
  c include: .\config
  asm define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c lls_client.c
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.1.0, Board Support:bsp_btn_ble 8.1.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_BLE:BLE_Modules:ble_common 3.0.0, nRF_BLE:BLE_Modules:ble_conn_params 3.0.0, nRF_BLE:BLE_Modules:ble_db_discovery 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_BLE:BLE_Modules:device_manager 3.0.0, nRF_BLE:BLE_Services:ble_lls 3.0.0, nRF_Drivers:app_uart 3.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Libraries:app_button 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_fifo 3.0.0, nRF_Libraries:app_scheduler 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Libraries:retarget 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s130 1.0.0
